# IAR project 258g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\CortexLib\AbstractHardware\Registers; ..\..\CortexLib\AbstractHardware\Registers\STM32F411; ..\..\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; ..\..\CortexLib\AbstractHardware; ..\..\CortexLib\Common; ..\..\..\CortexLib\AbstractHardware\Registers\STM32F411; F:\Github\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 258g.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
  group Hardware/Pin
    ./: iPIN.h Pin.cpp pin.h
