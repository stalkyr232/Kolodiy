<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\POIP\MyFirstProjct\First.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\POIP\MyFreeProject\MyFreeProject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\POIP\MyNewProject\MyNewProject.ewp</path>
    </project>
    <batchBuild />
</workspace>
