<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\Github\POIP\MyFirstProjct\First.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\Github\POIP\MyNewProject\MyNewProject.ewp</path>
    </project>
    <batchBuild />
</workspace>
