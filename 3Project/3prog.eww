<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\2.1project\2.2prog.ewp</path>
    </project>
    <batchBuild />
</workspace>
