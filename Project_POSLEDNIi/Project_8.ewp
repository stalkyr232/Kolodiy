# IAR project Project_8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: F:\Github\CortexLib\AbstractHardware\Registers; F:\Github\CortexLib\AbstractHardware\Registers\STM32F411; F:\Github\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; F:\Github\CortexLib\Common; F:\Github\Kolodiy\Project_POSLEDNIi\Hardware; F:\Github\Kolodiy\Project_POSLEDNIi\Hardware\Pin; F:\Github\Kolodiy\Project_POSLEDNIi\Components; F:\Github\Kolodiy\Project_POSLEDNIi\Components\Button; F:\Github\Kolodiy\Project_POSLEDNIi\Components\LED; F:\Github\Kolodiy\Project_POSLEDNIi\Modes; F:\Github\Kolodiy\Project_POSLEDNIi\Modes\AllMode; F:\Github\Kolodiy\Project_POSLEDNIi\Modes\ChessMode; F:\Github\Kolodiy\Project_POSLEDNIi\Modes\TreeMode; F:\Github\Kolodiy\Project_POSLEDNIi; F:\Github\Kolodiy\Project_POSLEDNIi\Modes\Slide
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project_8.srec
  ILINK.IlinkOutputFile: Project_8.out
  ILINK.IlinkIcfFile: F:\Github\Kolodiy\Project_POSLEDNIi\Project_8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp
  group Components/Button
    Components/Button/: Button.cpp IButton.h IPinReadable.h
  group Components/LED
    Components/LED/: ILED.h LED.cpp
  group Hardware/Pin
    Hardware/Pin/: Fake.h ipin.h pin.h pinconfig.h
  group Modes
    Modes/: Garland.h IMode.h
  group Modes/AllMode
    Modes/AllMode/: AllMode.cpp
  group Modes/ChessMode
    Modes/ChessMode/: ChessMode.cpp
  group Modes/Slide
    Modes/Slide/: SlideMode.cpp
  group Modes/TreeMode
    Modes/TreeMode/: TreeMode.cpp
